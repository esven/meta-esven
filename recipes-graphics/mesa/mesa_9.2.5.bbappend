PROVIDES_remove = "virtual/libgl virtual/mesa"